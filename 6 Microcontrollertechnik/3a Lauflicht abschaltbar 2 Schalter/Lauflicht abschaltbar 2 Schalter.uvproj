# Keil uVision project Lauflicht abschaltbar 2 Schalter.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: Lauflicht abschaltbar 2 Schalter
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Lauflicht abschaltbar 2 Schalter.c
